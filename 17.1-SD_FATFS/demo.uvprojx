# Keil uVision project demo.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: demo +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\CMSIS;.\Lib\inc;.\Startup;.\User;.\System\delay;.\System\sys;.\Hardware\LED;.\System\reg;.\Hardware\KEY;.\Hardware\BEEP;.\System\usart;.\System\timer;.\Hardware\ADC;.\Hardware\DMA;.\Hardware\LCD;.\System\IWDT;.\System\WWDT;.\Hardware\W25Q128;.\Hardware\IIC;.\Hardware\SPI;.\Hardware\FAT;.\Hardware\SDIO
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMISI
    ./CMSIS/: core_cm3.c
  group Lib
    ./Lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ./User/: main.c stm32f10x_it.c system_stm32f10x.c
  group Startup
    ./Startup/: startup_stm32f10x_hd.s
  group System
    ./System/delay/: delay.c
    ./System/sys/: sys.c
    ./System/usart/: usart.c
    ./System/timer/: timer.c
    ./System/IWDT/: iwdt.c
    ./System/WWDT/: wwdt.c
  group Hardware
    ./Hardware/LED/: led.c
    ./Hardware/KEY/: key.c
    ./Hardware/BEEP/: beep.c
    ./Hardware/ADC/: adc.c
    ./Hardware/DMA/: MyDMA.c
    ./Hardware/IIC/: iic.c
    ./Hardware/SPI/: spi.c
    ./Hardware/W25Q128/: w25q128.c
    ./Hardware/FAT/: diskio.c ff.c ffsystem.c ffunicode.c
    ./Hardware/SDIO/: stm32_sdio_sd.c
